# Keil uVision project atk_f103.uvprojx, settings and files
target SparkAi (6240000::V6.24::ARMCLANG)
  device: APM32E103RE Geehy
  pack: Geehy.APM32E1xx_DFP.1.0.3
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: atk_f103
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: E:\LBS-SPARK-AI\postbuild.bat
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE,PIKA_CONFIG_ENABLE
  c include: ..\..\Users;..\..\Drivers;..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Middlewares\event_manager;..\..\Drivers\BSP\LED;..\..\Drivers\BSP\TIMER;..\..\Drivers\BSP\KEY;..\..\Middlewares\malloc;..\..\Middlewares\usb\STM32_USB_Device_Library\Class\CDC\Inc;..\..\Middlewares\usb\STM32_USB_Device_Library\Core\Inc;..\..\Middlewares\usb\USB_APP;..\..\Middlewares\usb\USB_HAL;..\..\Middlewares\protocol;..\..\Drivers\BSP\STMFLASH;..\..\python\pikascript-core;..\..\python\pikascript-api;..\..\python\pikascript-lib\PikaStdLib;..\..\Drivers\BSP\ADC;..\..\Drivers\BSP\IIC;..\..\Drivers\BSP\SPI;..\..\Middlewares\deviceIdentify;..\..\application\beep;..\..\application\matrix;..\..\application\motor;..\..\Drivers\BSP\WDG;..\..\application\blue;..\..\application\color;..\..\application\touch;..\..\application\ultrasion;..\..\Middlewares\fatfs\source;..\..\Middlewares\fatfs\exfuns;..\..\Middlewares\w25q80x;..\..\Middlewares\lbs_file_manager;..\..\Middlewares\monitor;..\..\Middlewares\bat_manager;..\..\Middlewares\RTC
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group application
    ../../application/beep/: beep.c
    ../../application/motor/: motor.c
    ../../application/blue/: blue.c
    ../../application/color/: color.c
    ../../application/touch/: touch.c
    ../../application/ultrasion/: ultrasion.c
  group WillAi/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/TIMER/: btim.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/STMFLASH/: stmflash.c
    ../../Drivers/BSP/ADC/: adc.c
    ../../Drivers/BSP/IIC/: iic.c
    ../../Drivers/BSP/SPI/: spi.c
    ../../Drivers/BSP/WDG/: wdg.c
  group User
    ../../Users/: main.c stm32f1xx_it.c pika_config.c pika_config.h
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c
  group WillAi/Middle
    ../../application/matrix/: ui_manager.c animation.c display.c font.c led_matrix.c tm1640.c matrix_port.c
    ../../Middlewares/event_manager/: event_manager.c
    ../../Middlewares/malloc/: malloc.c
    ../../Middlewares/protocol/: protocol.c
    ../../Middlewares/lbs_file_manager/: lbsfilemanager.c
    ../../Middlewares/deviceIdentify/: deviceIdentify.c
    ../../Middlewares/w25q80x/: w25q80.c
    ../../Middlewares/monitor/: json-maker.c monitor.c
    ../../Middlewares/bat_manager/: bat_manager.c
  group Middle/USB_CORE
    ../../Middlewares/usb/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middle/USB_CLASS
    ../../Middlewares/usb/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middle/USB_APP
    ../../Middlewares/usb/USB_APP/: usbd_cdc_interface.c usbd_conf.c usbd_desc.c
  group Middle/USB_HAL
    ../../Middlewares/usb/USB_HAL/: stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c
  group pikascript-core
    ../../python/pikascript-core/: BaseObj.c dataArg.c dataArgs.c dataLink.c dataLinkNode.c dataMemory.c dataQueue.c dataQueueObj.c dataStack.c dataString.c dataStrs.c PikaCompiler.c PikaObj.c PikaParser.c PikaPlatform.c PikaVM.c TinyObj.c
  group pikascript-api
    ../../python/pikascript-api/: __asset_pikaModules_py_a.c __pikaBinding.c pikaScript.c
  group pikascript-lib
    ../../python/pikascript-lib/PikaStdLib/: PikaDebuger_Debuger.c PikaStdData_ByteArray.c PikaStdData_Dict.c PikaStdData_FILEIO.c PikaStdData_List.c PikaStdData_String.c PikaStdData_Tuple.c PikaStdData_Utils.c PikaStdLib_MemChecker.c PikaStdLib_RangeObj.c PikaStdLib_StringObj.c PikaStdLib_SysObj.c PikaStdTask_Task.c
    ../../python/pikascript-lib/ExternLib/: _motor.c _os.c _color.c _touch.c _ultrasion.c _key.c _matrix.c _beep.c
    ../../python/pikascript-lib/random/: _random.c
    ../../python/pikascript-lib/math/: _math.c
  group Middle/FATFS
    ../../Middlewares/fatfs/source/: diskio.c ff.c ffsystem.c ffunicode.c
    ../../Middlewares/fatfs/exfuns/: exfuns.c
  group Readme
    ../../: readme.txt
